# Keil uVision project Object.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Object +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c note.c MatrixScreen.c MatrixScreen.h Delay.c Delay.h UART.c UART.h
