# Keil uVision project 123132.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Object +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: AT24C02.c AT24C02.h Delay.c Delay.h DHT11.c DHT11.h I2C.c I2C.h Key.c Key.h LCD1602.c LCD1602.h main.c Timer0.c Timer0.h SYN6288.c SYN6288.h
